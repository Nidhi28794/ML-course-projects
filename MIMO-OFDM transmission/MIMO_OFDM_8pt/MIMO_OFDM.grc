options:
  parameters:
    generate_options: qt_gui
    id: MIMO_OFDM
    output_language: python
    title: MIMO_2x2_OFDM
  states: {}

blocks:
- name: Nc
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: OFDM_8pt_0
  id: OFDM_8pt
  parameters:
    t1: '1'
    t2: '0'
    t3: '0'
  states: {}
- name: OFDM_8pt_0_0
  id: OFDM_8pt
  parameters:
    t1: '1'
    t2: '0'
    t3: '0'
  states: {}
- name: OFDM_8pt_0_0_0
  id: OFDM_8pt
  parameters:
    t1: '-1'
    t2: '0'
    t3: '0'
  states: {}
- name: OFDM_8pt_0_0_0_0
  id: OFDM_8pt
  parameters:
    t1: '1'
    t2: '0'
    t3: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((1/16, 1/16), (1/16, -1/16))
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: int
    out_type: complex
    symbol_table: (1+1j,-1+1j,-1-1j,1-1j)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Received_MIMO OFDM"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Tx_MIMO OFDM"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}

connections:
- [OFDM_8pt_0, '0', blocks_add_xx_0, '0']
- [OFDM_8pt_0_0, '0', blocks_add_xx_0, '1']
- [OFDM_8pt_0_0_0, '0', blocks_add_xx_1, '0']
- [OFDM_8pt_0_0_0_0, '0', blocks_add_xx_1, '1']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_matrix_xx_0, '1']
- [blocks_deinterleave_0, '0', OFDM_8pt_0, '0']
- [blocks_deinterleave_0, '0', OFDM_8pt_0_0_0, '0']
- [blocks_deinterleave_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_deinterleave_0, '1', OFDM_8pt_0_0, '0']
- [blocks_deinterleave_0, '1', OFDM_8pt_0_0_0_0, '0']
- [blocks_deinterleave_0, '1', qtgui_const_sink_x_0_0, '1']
- [blocks_multiply_matrix_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_matrix_xx_0, '1', qtgui_const_sink_x_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
