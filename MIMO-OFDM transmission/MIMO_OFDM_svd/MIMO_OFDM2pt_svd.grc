options:
  parameters:
    author: nidhi
    generate_options: qt_gui
    id: MIMO_2x2OFDM_svd
    output_language: python
    title: MIMO_2x2OFDM_svd
  states: {}

blocks:
- name: Nc
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: OFDM_2pt_rx_0
  id: OFDM_2pt_rx
  parameters:
    t1: '1'
    t2: '0'
  states: {}
- name: OFDM_2pt_rx_0_0_0_0
  id: OFDM_2pt_rx
  parameters:
    t1: '1'
    t2: '0'
  states: {}
- name: OFDM_2pt_tx_0
  id: OFDM_2pt_tx
  parameters:
    t1: '1'
    t2: '0'
  states: {}
- name: OFDM_2pt_tx_0_0
  id: OFDM_2pt_tx
  parameters:
    t1: '1'
    t2: '0'
  states: {}
- name: OFDM_2pt_tx_0_0_0
  id: OFDM_2pt_tx
  parameters:
    t1: '-1'
    t2: '0'
  states: {}
- name: OFDM_2pt_tx_0_0_0_0
  id: OFDM_2pt_tx
  parameters:
    t1: '1'
    t2: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((-1,0),(0,-1))
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_1_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((-0.707,-0.707), (-0.707, -0.707))
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_2
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((1/1.414, 0), (0, 1/1.414))
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: int
    out_type: complex
    symbol_table: (1+1j,-1+1j,-1-1j,1-1j)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Received_MIMO OFDM"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Txed_MIMO OFDM"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Received_MIMO OFDM_add"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Received_MIMO OFDM"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: svd_n
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np
      from scipy.linalg import svd
      h = np.zeros((16,16))
      for i in range (0,16):
      	for j in range(0,16):
      		if((i+j)%8 == 2):
      			h[i,j] = 1
      for i in range (0,16):
      	for j in range(0,16):
      		if((i+j)%8 == 1):
      			h[i,j] = 1

      for i in range (8,16):
      	for j in range(8,16):
      		if((i+j)%8 == 1):
      			h[i,j] = -1
      U,s,V = svd(h) 
      UT = np.transpose(U);
      a=UT.tolist();
      b=V.tolist();
  states: {}

connections:
- [OFDM_2pt_rx_0, '0', blocks_add_xx_2, '0']
- [OFDM_2pt_rx_0, '0', blocks_add_xx_3, '0']
- [OFDM_2pt_rx_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [OFDM_2pt_rx_0_0_0_0, '0', blocks_add_xx_2, '1']
- [OFDM_2pt_rx_0_0_0_0, '0', blocks_add_xx_3, '1']
- [OFDM_2pt_rx_0_0_0_0, '0', qtgui_const_sink_x_0_1_0, '1']
- [OFDM_2pt_tx_0, '0', blocks_add_xx_0, '0']
- [OFDM_2pt_tx_0_0, '0', blocks_add_xx_1, '0']
- [OFDM_2pt_tx_0_0_0, '0', blocks_add_xx_1, '1']
- [OFDM_2pt_tx_0_0_0_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_add_xx_0, '0', OFDM_2pt_rx_0, '0']
- [blocks_add_xx_1, '0', OFDM_2pt_rx_0_0_0_0, '0']
- [blocks_add_xx_2, '0', blocks_multiply_matrix_xx_1_0, '0']
- [blocks_add_xx_2, '0', qtgui_const_sink_x_0_1, '0']
- [blocks_add_xx_3, '0', blocks_multiply_matrix_xx_1_0, '1']
- [blocks_add_xx_3, '0', qtgui_const_sink_x_0_1, '1']
- [blocks_deinterleave_0, '0', blocks_multiply_matrix_xx_0_0, '0']
- [blocks_deinterleave_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_matrix_xx_0_0, '1']
- [blocks_deinterleave_0, '1', qtgui_const_sink_x_0_0, '1']
- [blocks_multiply_matrix_xx_0_0, '0', OFDM_2pt_tx_0, '0']
- [blocks_multiply_matrix_xx_0_0, '0', OFDM_2pt_tx_0_0, '0']
- [blocks_multiply_matrix_xx_0_0, '1', OFDM_2pt_tx_0_0_0, '0']
- [blocks_multiply_matrix_xx_0_0, '1', OFDM_2pt_tx_0_0_0_0, '0']
- [blocks_multiply_matrix_xx_1_0, '0', blocks_multiply_matrix_xx_2, '0']
- [blocks_multiply_matrix_xx_1_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_matrix_xx_1_0, '1', blocks_multiply_matrix_xx_2, '1']
- [blocks_multiply_matrix_xx_1_0, '1', qtgui_const_sink_x_0, '1']
- [blocks_multiply_matrix_xx_2, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_matrix_xx_2, '1', qtgui_const_sink_x_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
