options:
  parameters:
    author: nidhi
    category: MIMO_OFDM
    generate_options: hb
    id: OFDM_2pt_tx
    output_language: python
    title: OFDM_2pt_tx
  states: {}

blocks:
- name: Nc
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_deinterleave_1
  id: blocks_deinterleave
  parameters:
    num_streams: '3'
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '3'
    type: complex
  states: {}
- name: blocks_interleave_1
  id: blocks_interleave
  parameters:
    num_streams: Nc
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nc
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: Nc
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nc
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nc
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: Nc
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(Nc)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: Nc
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(Nc)
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: ((t1,t2))
    type: ccc
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: t1
  id: parameter
  parameters:
    label: tap t1
    value: '1'
  states: {}
- name: t2
  id: parameter
  parameters:
    label: tap t2
    value: '0'
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_interleave_0, '1']
- [blocks_deinterleave_0, '1', blocks_interleave_0, '0']
- [blocks_deinterleave_0, '1', blocks_interleave_0, '2']
- [blocks_deinterleave_1, '0', blocks_null_sink_0, '0']
- [blocks_deinterleave_1, '1', blocks_interleave_1, '0']
- [blocks_interleave_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_deinterleave_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [interp_fir_filter_xxx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
